# IAR project Project.ewp, settings and files
configuration STM32303C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; USE_STM32303C_EVAL
  ICCARM.CCIncludePath2: ..\; ..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\Libraries\STM32F30x_I2C_CPAL_Driver\inc; ..\Utilities\STM32_EVAL\Common; ..\Utilities\STM32_EVAL\STM32303C_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32303C-EVAL.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration TERMOM STM32F303 (ARM, debug)
  as the first configuration, except:
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group EWARM
    ../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
  group StdPeriph_Drivers
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group STM32_EVAL
    ../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
  group User
    ../: calibration.c crc.c eeprom.c hw_config.c interpolation.c keyboard.c main.c stm32f30x_it.c
